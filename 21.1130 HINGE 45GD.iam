# Autodesk Inventor assembly: 21.1130 HINGE 45GD
## iProperties
Created: 2007-01
Part Number: 21.1130 HINGE 45GD
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
